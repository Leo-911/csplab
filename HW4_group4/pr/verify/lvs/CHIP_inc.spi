.INCLUDE /usr/cad/CBDK/Executable_Package/Collaterals/IP/stdcell/N16ADFP_StdCell/SPICE/N16ADFP_StdCell_100b.spi
.INCLUDE /usr/cad/CBDK/Executable_Package/Collaterals/IP/sram/N16ADFP_SRAM/SPICE/N16ADFP_SRAM_100a.spi
.INCLUDE /usr/cad/CBDK/Executable_Package/Collaterals/IP/stdio/N16ADFP_StdIO/SPICE/N16ADFP_StdIO.spi
.INCLUDE CHIP.spi
